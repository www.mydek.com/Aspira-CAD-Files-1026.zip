Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2024-04-30T15:58:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 23.0.13600.0000 - Exporter 19.0.0.401 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 30 15:58:35 2024 * Host: LAPTOP-U55UI3S5 * Database: C:\Users\seb2c\AppData\Local\Temp\{F6ACCEE8-3920-46AE-917D-0897372699C4}\ifc * Database version: 5507 * Database creation date: Tue Apr 30 15:58:34 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 30 15:58:34 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 30 15:58:34 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Aspira Plus - Decking, Family1:Aspira Plus - Decking:201923
In: Level 1
Type - Material: 254_254_255
Type - Identity Data - Description: Aspira + Insert; Manufacturer: Mydek; Model: Aspira Plus; Type Name: Aspira Plus - Decking; URL: mydek.com
Type - Other - Category: Generic Models; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Aspira Plus - Decking
Pset_ManufacturerTypeInformation - Manufacturer: Mydek
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.588457 m2; Volume: 0.00106614 m3
Other - Family: Family1: Aspira Plus - Decking; Family and Type: Family1: Aspira Plus - Decking; Type: Family1: Aspira Plus - Decking; Type Id: Family1: Aspira Plus - Decking
Phasing - Phase Created: New Construction
